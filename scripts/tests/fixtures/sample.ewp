# IAR project sample.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10WMG RL78 - R5F10WMG
  ICCRL78.CCDefines: _CODE_DEBUG_; USE_ASSERT
  ICCRL78.CCIncludePath2: ..\Code; ..\Code\bsp; ..\Code
  ICCRL78.IccExtraOptions: --nonsense
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: DEF_RELEASE
  ICCRL78.CCIncludePath2: ..\Code
  ICCRL78.IccExtraOptions: --no_cse
  group app
    ../Code/: main.c debug_only.c api.h
  group app/bsp
    ../Code/bsp/: board.c
