# Keil uVision project sample.uvprojx, settings and files
target App ()
  group 
    ./User/: main.c
    ./bsp/: led.c
